## src/modules/vtx_control/Kconfig
```kconfig
menuconfig MODULES_VTX_CONTROL
	bool "vtx_control"
	default n
	---help---
		Enable support for vtx_control
```
